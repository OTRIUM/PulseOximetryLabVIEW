<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MAXREFDES117F1.ewp</path>
  </project>
  <batchBuild />
</workspace>
